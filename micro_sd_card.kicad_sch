File: micro_sd_card.kicad_sch (KiCad schematic)
At the start: 7 parts, among them J33 Micro_SD_Card

Commit message: Update
Other:
- moved on the sheet: J33, R40, R41, R42, R43, R44, R45
